FILESEXTRAPATHS_prepend := "${THISDIR}/${BPN}-${PV}:" 

SRC_URI += "file://0001-ARM-u-boot-ccimx6ulsbc-enable-on-SBC-4GB-eMMC.patch"

