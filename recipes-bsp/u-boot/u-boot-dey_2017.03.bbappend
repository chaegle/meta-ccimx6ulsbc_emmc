FILESEXTRAPATHS_prepend := "${THISDIR}/${BPN}-${PV}:"

SRC_URI += "file://0001-ARM-u-boot-enable-on-SBC-4GB-eMMC.patch"

